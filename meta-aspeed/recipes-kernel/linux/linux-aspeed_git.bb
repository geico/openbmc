KBRANCH ?= "dev-6.18"
LINUX_VERSION ?= "6.18.50"

SRCREV = "3a7b2a135e6b2628768fef537590c5b5bdb6fe7a"

require linux-aspeed.inc
